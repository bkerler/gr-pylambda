options:
  parameters:
    author: jacob
    generate_options: qt_gui
    id: pdu_lambda_example
    output_language: python
    title: PDU Lambda Example
  states: {}

blocks:
- name: k
  id: variable_qtgui_range
  parameters:
    label: Scale
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_NIL
    period: '500'
  states: {}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("distance")
    v: pmt.from_double(123)
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This flowgraph shows some potential uses for the PDU and
      message lambda blocks. The Message lambda converts a u8vector
      PMT into a PDU, which has a key added. Two PDU lambda blocks
      then operate on the uniform vector part and the metadata part
      respectively.
    note: Flowgraph Summary
  states: {}
- name: pylambda_message_lambda_0
  id: pylambda_message_lambda
  parameters:
    fn: 'lambda msg: pmt.cons(pmt.make_dict(), msg)'
  states: {}
- name: pylambda_pdu_lambda_0
  id: pylambda_pdu_lambda
  parameters:
    fn: 'lambda x: x*k'
    key: ''
    metadict: Uniform Vector
  states: {}
- name: pylambda_pdu_lambda_1
  id: pylambda_pdu_lambda
  parameters:
    fn: 'lambda x: x*12'
    key: pmt.intern("distance")
    metadict: Metadata
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    key: pmt.dict
    label: Uniform Vector
    type: int_vec
    value: 1,2,3,4
  states: {}

connections:
- [blocks_message_strobe_1, strobe, pylambda_message_lambda_0, msg]
- [blocks_pdu_set_0, pdus, pylambda_pdu_lambda_0, pdu]
- [blocks_pdu_set_0, pdus, pylambda_pdu_lambda_1, pdu]
- [pylambda_message_lambda_0, msg, blocks_pdu_set_0, pdus]
- [pylambda_pdu_lambda_0, pdu, blocks_message_debug_1, print_pdu]
- [pylambda_pdu_lambda_1, pdu, blocks_message_debug_1, print]
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_1, set_msg]

metadata:
  file_format: 1
