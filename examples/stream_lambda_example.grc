options:
  parameters:
    author: jacob
    generate_options: qt_gui
    id: stream_lambda_example
    output_language: python
    title: Stream Lambda Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This flowgraph shows an example use of the stream lambda block
      where it samples every other input from a complex sinusoid and
      takes these values to the second and third power respectively on
      two outputs.
    note: Flowgraph Summary
  states: {}
- name: pylambda_stream_lambda_0
  id: pylambda_stream_lambda
  parameters:
    fn: 'lambda input_items, output_index: (input_items[0][::2]**(output_index+2))*0.1'
    inports: '1'
    intype: complex
    outports: '2'
    outtype: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0_0, '0', pylambda_stream_lambda_0, '0']
- [pylambda_stream_lambda_0, '0', qtgui_freq_sink_x_0, '1']
- [pylambda_stream_lambda_0, '1', qtgui_freq_sink_x_0, '2']

metadata:
  file_format: 1
